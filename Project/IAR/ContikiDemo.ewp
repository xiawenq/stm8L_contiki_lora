# IAR project ContikiDemo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\..; ..\..\Application\Include; ..\..\Driver\STM8L15x_StdPeriph_Driver\inc; ..\..\Driver\Include; ..\..\Contiki\ports; ..\..\Contiki\core; ..\..\Contiki\core\sys; ..\..\RF; ..\..\Driver\LoRaMac_Driver\inc; ..\..\Driver\LoRaMac_Driver\inc\region; ..\..\Driver\SX1276_Driver\inc; ..\..\Driver\boards; ..\..\Driver\boards\system; ..\..\Driver\boards\system\crypto
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ContikiDemo.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../../: main.c
  group Application
    ../../Application/Source/: Dbg.c Demo.c Monitor.c Util.c
  group Contiki/core/lib
    ../../Contiki/core/lib/: assert.c checkpoint.c crc16.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group Contiki/core/sys
    ../../Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group Contiki/ports
    ../../Contiki/ports/: clock.c rtimer-arch.c
  group Driver
    ../../Driver/Source/: Chip.c DebugPort.c Key.c SHT1x.c stm8l15x_it.c Wdg.c
  group Driver/STM8L15x_StdPeriph_Driver
    ../../Driver/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim1.c stm8l15x_tim5.c stm8l15x_usart.c
  group RF/boards
    ../../Driver/boards/: board.c
  group RF/boards/system
    ../../Driver/boards/system/: utilities.c
  group RF/boards/system/crypto
    ../../Driver/boards/system/crypto/: aes.c cmac.c
  group RF/SX1276_Driver
    ../../Driver/SX1276_Driver/src/: sx1276.c
