<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\Application\Source\Dbg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Application\Source\Demo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Application\Source\Monitor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Application\Source\Util.c</name>
    </file>
  </group>
  <group>
    <name>Contiki</name>
    <group>
      <name>core</name>
      <group>
        <name>lib</name>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\assert.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\checkpoint.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\crc16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\gcr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\ifft.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\libconio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\list.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\me.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\me_tabs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\memb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\mmem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\petsciiconv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\print-stats.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\random.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\ringbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\sensors.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\settings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\strncasecmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\lib\trickle-timer.c</name>
        </file>
      </group>
      <group>
        <name>sys</name>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\arg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\autostart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\compower.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\ctimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\energest.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\etimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\process.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\procinit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\profile.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\rtimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\stimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\timetable-aggregate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Contiki\core\sys\timetable.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>ports</name>
      <file>
        <name>$PROJ_DIR$\..\..\Contiki\ports\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Contiki\ports\rtimer-arch.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Driver</name>
    <group>
      <name>STM8L15x_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\Chip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\DebugPort.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\Key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\SHT1x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Driver\Source\Wdg.c</name>
    </file>
  </group>
  <group>
    <name>RF</name>
    <group>
      <name>boards</name>
      <group>
        <name>system</name>
        <group>
          <name>crypto</name>
          <file>
            <name>$PROJ_DIR$\..\..\Driver\boards\system\crypto\aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Driver\boards\system\crypto\cmac.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\Driver\boards\system\utilities.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\boards\board.c</name>
      </file>
    </group>
    <group>
      <name>LoRaMac_Driver</name>
      <group>
        <name>region</name>
      </group>
    </group>
    <group>
      <name>SX1276_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\Driver\SX1276_Driver\src\sx1276.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\main.c</name>
  </file>
</project>


